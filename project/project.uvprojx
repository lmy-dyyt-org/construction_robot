# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __perf_counter_printf__=rt_kprintf, ARDUINO_ARCH_RTTHREAD=10000, USE_HAL_DRIVER, RT_USING_LIBC, printf=rt_kprintf, __CLK_TCK=RT_TICK_PER_SECOND, STM32F427xx, __PERF_CNT_USE_RTOS__, __RTTHREAD__, ARDUINO=10819
  c include: rt-thread\components\drivers\include;applications\chassis;rt-thread\components\libc\posix\io\eventfd;packages\RTduino-latest\core;board;board\CubeMX_Config\Inc;applications\statemachine;packages\perf_counter-v2.2.4.1;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;libraries\HAL_Drivers\drivers\config;applications\FasionStar;applications\interpolation;packages\RTduino-latest\libraries\buildin\Servo;applications\robotManager;packages\CmBacktrace-v1.4.1;rt-thread\components\libc\posix\ipc;applications;rt-thread\components\utilities\ulog;libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;libraries\HAL_Drivers\CMSIS\Include;rt-thread\libcpu\arm\common;packages\slcan2rtt-latest\inc;rt-thread\components\libc\cplusplus;libraries\HAL_Drivers\drivers;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\posix\io\poll;rt-thread\include;rt-thread\components\libc\posix\io\epoll;packages\FlexibleButton-v1.0.0;rt-thread\components\libc\compilers\common\include;rt-thread\components\finsh;board\ports;.;applications\arduino_pinout;packages\RTduino-latest\libraries\buildin\Wire;libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;rt-thread\libcpu\arm\cortex-m4;applications\abus;libraries\HAL_Drivers;rt-thread\components\drivers\include;rt-thread\components\drivers\include;packages\RTduino-latest\libraries\user;rt-thread\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/FasionStar/: fashion_star_uart_servo.c servo_port.c
    applications/: aboard_power_switch.c apid.c apid_exfunc.c arduino_main.cpp bsp_sbus.c data_analysis.c drv_action.c drv_corexy.c drv_emm_v5.c drv_tft_lq_tft18.c main.c motor.c motor_cfg.c motor_dj_rm_driver.c robot_move_direct.c
    applications/abus/: abus_port.c abus_topic.c afifo.c
    applications/chassis/: chassis.c chassis_module_mai.c chassis_port.c
    applications/interpolation/: LinearInterp.c cspline.c itpl_circle.c
    applications/robotManager/: robotmanager.c
    applications/statemachine/: cvector.c statemachine.c
  group cm_backtrace
    packages/CmBacktrace-v1.4.1/: cm_backtrace.c cmb_flash_log.c cmb_port.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    rt-thread/components/libc/cplusplus/: cxx_crt.cpp cxx_crt_init.c
  group DeviceDrivers
    rt-thread/components/drivers/can/: can.c
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: adc.c rt_drv_pwm.c
    rt-thread/components/drivers/pin/: pin.c
    rt-thread/components/drivers/serial/: serial_v2.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    libraries/HAL_Drivers/drivers/: drv_adc.c drv_can.c drv_gpio.c drv_pwm.c drv_soft_i2c.c drv_tim.c drv_usart_v2.c
    libraries/HAL_Drivers/: drv_common.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f427xx.s
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group flex_button
    packages/FlexibleButton-v1.0.0/: flexible_button.c flexible_button_demo.c
  group Kernel
    rt-thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_lptim.c stm32f4xx_hal_qspi.c stm32f4xx_hal_adc.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_tim.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_can.c stm32f4xx_hal_cryp.c stm32f4xx_hal.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_gpio.c
    libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group perf_counter
    packages/perf_counter-v2.2.4.1/os/: perf_os_patch_rt_thread.c
    packages/perf_counter-v2.2.4.1/: perf_counter.c
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group RTduino
    applications/arduino_pinout/: pins_arduino.c
  group RTduino-core
    packages/RTduino-latest/core/: Print.cpp wiring_analog.c Tone.cpp WMath_cpp.cpp wiring_shift.c HardwareSerial.cpp RTduino.cpp WString.cpp WInterrupts.c wiring.c IPAddress.cpp Stream.cpp wiring_digital.c WMath_c.c wiring_pulse.c
    packages/RTduino-latest/core/avr/: avr_stdlib.c
  group RTduino-libraries-buildin
    packages/RTduino-latest/libraries/buildin/Servo/: Servo.cpp
    packages/RTduino-latest/libraries/buildin/Wire/: Wire.cpp
  group slcan
    packages/slcan2rtt-latest/src/: slcan.c
  group Utilities
    rt-thread/components/utilities/ulog/: ulog.c
    rt-thread/components/utilities/ulog/backend/: console_be.c
